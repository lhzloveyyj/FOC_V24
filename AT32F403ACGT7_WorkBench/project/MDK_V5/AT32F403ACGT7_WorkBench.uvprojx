# Keil uVision project AT32F403ACGT7_WorkBench.uvprojx, settings and files
target AT32F403ACGT7_WorkBench (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ACGT7_WorkBench +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/usbd_drivers/inc;..\tools\LOG;..\app\MT6701;..\tools\Math;..\app\Delay;..\app\Control;..\app\FOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_debug.c usb_app.c wk_usbfs.c wk_acc.c wk_spi.c wk_gpio.c wk_tmr.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_gpio.c at32f403a_407_pwc.c at32f403a_407_spi.c at32f403a_407_flash.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group middlewares/usbd_driver
    ../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group tools
    ../tools/LOG/: LOG.c
    ../tools/Math/: fast_sin.h filter.c filter.h
  group app
    ../app/MT6701/: mt6701.c
    ../app/FOC/: FOC.c FOC.h foc_config.h SVPWM.c SVPWM.h
    ../app/Delay/: delay.c delay.h
    ../app/LED/: led.c led.h
  group usbd_class
    ../src/: cdc_class.c cdc_desc.c
